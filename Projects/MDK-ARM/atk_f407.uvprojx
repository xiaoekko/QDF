# Keil uVision project atk_f407.uvprojx, settings and files
target emWin (5060960::V5.06 update 7 (build 960)::.\5.06)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.0.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: atk_f407 +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F407xx
  c include: ..\..\User;..\..\Drivers;..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\Drivers\CMSIS\Include;..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\Middlewares;..\..\Middlewares\emWin\Config;..\..\Middlewares\emWin\inc;..\..\Middlewares\emWin\emWin_Demo;..\..\Middlewares\uC-OS3\uC-CPU\Cfg\Template;..\..\Middlewares\uC-OS3\uC-CPU\ARM-Cortex-M\ARMv7-M\ARM;..\..\Middlewares\uC-OS3\uC-CPU;..\..\Middlewares\uC-OS3\uC-LIB\Cfg\Template;..\..\Middlewares\uC-OS3\uC-LIB;..\..\Middlewares\uC-OS3\uC-OS3\Cfg\Template;..\..\Middlewares\uC-OS3\uC-OS3\Ports\ARM-Cortex-M\ARMv7-M\ARM;..\..\Middlewares\uC-OS3\uC-OS3\Source;..\..\Drivers\FONTS;..\..\FreeModbus\modbus\ascii;..\..\FreeModbus\modbus\functions;..\..\FreeModbus\modbus\include;..\..\FreeModbus\modbus\rtu;..\..\FreeModbus\port;..\..\FreeModbus\modbus\tcp;..\..\Drivers\BSP\OTA;..\..\Drivers\SYSTEM\sys;..\..\Drivers\SYSTEM\delay;..\..\Drivers\BSP\IWDG
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Startup
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f407xx.s
  group User
    ../../User/: main.c stm32f4xx_it.c task.c UI.c keyapp.c USART_.c FreeModbusApp.c valve.c
    ../../Drivers/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group Drivers/SYSTEM
    ../../Drivers/SYSTEM/delay/: delay.c
    ../../Drivers/SYSTEM/sys/: sys.c
    ../../Drivers/SYSTEM/usart/: usart.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_usart.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_sram.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_spi.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_msp_template.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_iwdg.c
  group Drivers/BSP
    ../../Drivers/BSP/LED/: led.c
    ../../Drivers/BSP/LCD/: lcd.c
    ../../Drivers/BSP/KEY/: key.c
    ../../Drivers/BSP/PRESS/: press.c
    ../../Drivers/BSP/Brushless Motor/: brushless motor.c
    ../../Drivers/BSP/PushMotor/: pushmotor.c
    ../../Drivers/BSP/MAX31865/: max31865.c
    ../../Drivers/BSP/DI/: Intput.c
    ../../Drivers/BSP/DO/: Output.c
    ../../Drivers/BSP/PCF8563/: pcf8563.c rtciic.c
    ../../Drivers/BSP/MB85RC16/: iic.c mb85rc16.c
    ../../Drivers/BSP/W25QXX/: w25qxx.c
    ../../Drivers/BSP/SPI/: spi.c
    ../../Drivers/BSP/ADC/: adc.c
    ../../Drivers/BSP/OTA/: ota.c
    ../../Drivers/BSP/IWDG/: bsp_iwdg.c
  group Middlewares/emWin/Config
    ../../Middlewares/emWin/Config/: GUI_X_Touch_Analog.c GUIConf.c GUIDRV_Template.c LCDConf.c
  group Middlewares/emWin/Lib
    ../../Middlewares/emWin/Lib/: GUI_CM4F_L.lib
  group Middlewares/emWin/OS
    ../../Middlewares/emWin/OS/: GUI_X_uCOS.c
  group Middlewares/uC-OS3/BSP
    ../../Middlewares/uC-OS3/uC-CPU/BSP/Template/: bsp_cpu.c
    ../../Middlewares/uC-OS3/uC-OS3/Template/: bsp_os_dt.c
  group Middlewares/uC-OS3/CPU
    ../../Middlewares/uC-OS3/uC-CPU/ARM-Cortex-M/ARMv7-M/: cpu_c.c
    ../../Middlewares/uC-OS3/uC-CPU/ARM-Cortex-M/ARMv7-M/ARM/: cpu_a.asm
    ../../Middlewares/uC-OS3/uC-CPU/: cpu_core.c
  group Middlewares/uC-OS3/LIB
    ../../Middlewares/uC-OS3/uC-LIB/: lib_ascii.c lib_math.c lib_mem.c lib_str.c
  group Middlewares/uC-OS3/OS3
    ../../Middlewares/uC-OS3/uC-OS3/Cfg/Template/: os_app_hooks.c
    ../../Middlewares/uC-OS3/uC-OS3/Ports/ARM-Cortex-M/ARMv7-M/: os_cpu_c.c
    ../../Middlewares/uC-OS3/uC-OS3/Ports/ARM-Cortex-M/ARMv7-M/ARM/: os_cpu_a.asm
    ../../Middlewares/uC-OS3/uC-OS3/Source/: os_cfg_app.c os_core.c os_dbg.c os_flag.c os_mem.c os_msg.c os_mutex.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
  group FONTS
    ../../Drivers/FONTS/: SimSun_1616.c SimSun_2424.c
  group FreeModbus
    ../../FreeModbus/modbus/ascii/: mbascii.c
    ../../FreeModbus/modbus/functions/: mbfunccoils.c mbfuncdiag.c mbfuncdisc.c mbfuncholding.c mbfuncinput.c mbfuncother.c mbutils.c
    ../../FreeModbus/modbus/rtu/: mbcrc.c mbrtu.c
    ../../FreeModbus/modbus/: mb.c
    ../../FreeModbus/modbus/tcp/: mbtcp.c
  group FreeModbus_Port
    ../../FreeModbus/port/: portevent.c portserial.c porttimer.c
